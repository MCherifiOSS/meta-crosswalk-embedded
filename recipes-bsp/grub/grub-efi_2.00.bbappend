FILESEXTRAPATHS_prepend := "${THISDIR}/grub:"

SRC_URI += "file://silent.patch;patch=1"
